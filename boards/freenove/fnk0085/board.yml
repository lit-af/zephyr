## boards/freenove/fnk0085/board.yml
```yaml
board:
  name: fnk0085
  full_name: Freenove ESP32-S3-WROOM Camera Board
  vendor: freenove
  socs:
  - name: esp32s3
```
